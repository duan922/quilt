# Keil uVision project Progect.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Progect +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\inc;..\Libraries\src;..\Startup;..\User;..\MQTT;..\CMSIS;..\HARDWARE\SHT20;..\HARDWARE\IIC;..\HARDWARE\LOCK;..\HARDWARE\MAX31865;..\HARDWARE\USART2;..\HARDWARE\ADC;..\HARDWARE\MPU6050;..\HARDWARE\EXTI;..\HARDWARE\UART5;..\HARDWARE\WK2144
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: stm32f10x_it.c main.c System.c delay.c usart.c gpio.c ConfigModuleNoBlock.c cString.c iwdg.c timer.c DHT11.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_adc.c stm32f10x_exti.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group MQTT
    ../MQTT/: mqtt.c mqtt_msg.c BufferManage.c LoopList.c
  group HARDWARE
    ../HARDWARE/SHT20/: sht20.c
    ../HARDWARE/LOCK/: lock.c
    ../HARDWARE/MAX31865/: max31865.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/UART5/: uart5.c
    ../HARDWARE/WK2144/: wk2xxx_uart.c
    ../HARDWARE/EXTI/: exti.c
    ../: Readme.txt
